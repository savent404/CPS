# Keil uVision project json_test_F407VG.uvprojx, settings and files
target json_test_F407VG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F417VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: json_tset_F407VG
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F417xx
  c misc: --C99
  c include: ../Inc;C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/STM32F4xx_HAL_Driver/Inc;C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/CMSIS/Include;..\..\cJSON
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group FreeRTOS_CLI
    ../Src/: cmd-fun.c demo-handle.c FreeRTOS_CLI.c cpu_utils.c
  group json/uj
    ../../ujson4c/src/: ujdecode.c
    ../../ujson4c/3rdparty/: ultrajsondec.c
  group Application/MDK-ARM
    ./: startup_stm32f417xx.s
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c main.c stm32f4xx_it.c crc.c usart.c gpio.c freertos.c
  group Middlewares/FreeRTOS
    C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c timers.c list.c event_groups.c queue.c tasks.c
    C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/Saven/STM32Cube/Repository/STM32Cube_FW_F4_V1.14.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c
  group json/cjson
    ../../cJSON/: cJSON.c cJSON_Utils.c
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDIN 1.1.0, Compiler:I/O:STDOUT 1.1.0
